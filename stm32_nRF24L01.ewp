# IAR project stm32_nRF24L01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: HSE_VALUE=8000000; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: stm32f4_discovery; STM32F4xx_StdPeriph_Driver\inc; CMSIS\ST\STM32F4xx\Include; CMSIS\Include; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c nRF24L01.c nRF24L01.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group CMSIS
    CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    CMSIS/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group stm32f4_discovery
    stm32f4_discovery/: stm32f4_discovery.c stm32f4_discovery.h
  group STM32F4xx_StdPeriph_Driver
    STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c
